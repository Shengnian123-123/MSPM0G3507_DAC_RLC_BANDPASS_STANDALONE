# Keil uVision project LP_MSPM0G3507_ADC_SPI_TIMER.uvprojx, settings and files
target LP_MSPM0G3507_ADC_SPI_TIMER (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LP_MSPM0G3507_ADC_SPI_TIMER +hex
  BeforeMake: .\run_syscfg.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../Core/Inc,../application,../business,../function,../hardware,../bsp,../components/ad9959,../components/ad9833,../components/ads1220,../components/oled_ssd1306,../,D:/TI/M0_SDK/mspm0_sdk_2_11_00_07/source/third_party/CMSIS/Core/Include,D:/TI/M0_SDK/mspm0_sdk_2_11_00_07/source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Core
    ../Core/Src/: main.c
    ../Core/Inc/: main.h
    ./: startup_mspm0g350x_uvision.s
  group application
    ../application/: sys.c sys.h dac_waveform.c dac_waveform.h adc_apl.c adc_apl.h test_console.c test_console.h waveform_capture.c waveform_capture.h p1_lab.c p1_lab.h p2_lab.c p2_lab.h p3_lab.c p3_lab.h p4_lab.c p4_lab.h signal_tools_lab.c signal_tools_lab.h waveform_clone.c waveform_clone.h tjc_screen.c tjc_screen.h
  group business
    ../business/: adc_bll.c adc_bll.h system_bll.c system_bll.h app_error.c app_error.h app_params.c app_params.h
  group function
    ../function/: adc_fml.c adc_fml.h signal_filter.c signal_filter.h signal_measure.c signal_measure.h signal_spectral.c signal_spectral.h control_pid.c control_pid.h control_agc.c control_agc.h dual_sine_analyzer.c dual_sine_analyzer.h
  group bsp
    ../bsp/: mspm0g3507_board.c mspm0g3507_board.h
  group components
    ../components/ad9959/: ad9959.c ad9959.h
    ../components/ad9833/: ad9833.c ad9833.h
    ../components/ads1220/: ads1220.c ads1220.h
    ../components/oled_ssd1306/: oled_ssd1306.c oled_ssd1306.h
  group hardware
    ../hardware/: adc.c adc.h spi.c spi.h tim.c tim.h uart.c uart.h screen_uart.c screen_uart.h delay.c delay.h gpio_io.c gpio_io.h peripheral_status.c peripheral_status.h i2c_bus.c i2c_bus.h pwm_out.c pwm_out.h capture_input.c capture_input.h dma_port.c dma_port.h adc_dma_scope.c adc_dma_scope.h frequency_meter.c frequency_meter.h phase_meter.c phase_meter.h rms_meter.c rms_meter.h
  group SysConfig
    ../: adc_spi_timer.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
  group Driverlib
    D:/TI/M0_SDK/mspm0_sdk_2_11_00_07/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
